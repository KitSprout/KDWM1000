# Keil uVision project ProjectSTM32.uvprojx, settings and files
target KDWM1000 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F411C
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F411xE, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Libraries/CMSIS/Device/: startup_stm32f411xe.s system_stm32f4xx.c
  group Library
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
    ../Program/: stm32f4xx_conf.h
  group Driver
    ../Program/drivers/: stm32f4_delay.c stm32f4_usart.c
  group Math
    ../Libraries/CMSIS/DSP_Lib/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../Libraries/CMSIS/DSP_Lib/MatrixFunctions/: arm_mat_add_f32.c arm_mat_sub_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mat_scale_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c
  group Program
    ../Program/: main.c kdwm1000.c kdwm1000_bsp.c kdwm1000_it.c
  group Module
    ../Program/modules/: serial.c
  group Algorithm
    ../Program/algorithms/: string.c matrix_arm.c
